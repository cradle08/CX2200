# Keil uVision project CX100.uvprojx, settings and files
target CX100 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: CX2200 +hex
  AfterMake: fromelf --bin --output .\CX100\CX2200.bin .\CX100\CX2200.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,RTE_CMSIS_RTOS2
  c misc: --diag_suppress=188
  c include: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F; ..\STemWin\PNG_Lib; ..\STemWin\Menu\analysis; ..\STemWin\Menu; ..\STemWin\Inc; ..\STemWin\Config; ..\STemWin\OS; ..\RL_FlashFS; ..\RL_FlashFS\CMSIS-Driver2.6.1; ..\RL_FlashFS\FileSystem6.13.8; ..\App; ..\Algo\include; ..\User\Task; ..\STemWin\Menu\serviceItemPage; ..\Middlewares\Third_Party\FreeRTOS\Source; ..\cm_backtrace; ..\Middlewares\Third_Party\FatFs\src; ../Middlewares/ST/STM32_USB_Host_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc
  asm include: ..\Inc
  memory RVCT4: ROM 0x8008000 size 0xf8000
  memory RVCT9: RAM 0x20010000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User
    ../Src/: main.c gpio.c freertos.c adc.c crc.c dac.c dma.c dma2d.c usbh_diskio.c fatfs.c fmc.c i2c.c ltdc.c spi.c tim.c usart.c usb_host.c usbh_conf.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/App
    ../STemWin/Menu/: msg_def.h
    ../App/: Common.c Common.h parameter.c file_operate.c bc.c backend_msg.c ftl.c bsp_nand.c bsp_outin.c process.c bsp_press.c bsp_pump.c bsp_resistance.c bsp_sdram.c bsp_adc.c monitorV.c bsp_motor.c tp.c bsp_light.c xpt2046.c bsp_eeprom.c bsp_rtc.c unicode2gbk.c Printer.c PrinterTask.c serviceItems.c bsp_countsignal.c CAT_iot.c CAT_iotTask.c bsp_beep.c bsp_spi.c flash.c crc16.c pcba.c digPressure.c usart1CMD.c fatfs_UpanApp.c HGB_Deal.c ZhiJian.c
  group Application/Algo
    ../Algo/lib/: algo_V1.1.1.lib
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group STemWin/Config
    ../STemWin/Config/: GUIConf.c LCDConf_Lin_Template.c GUI_X_Touch.c GUI_Touch.c
  group STemWin/OS
    ../STemWin/OS/: GUI_X_OS.c
  group STemWin/Lib
    ../STemWin/Lib/: STemWin_CM4_OS_wc16.a
  group STemWin/Menu
    ../STemWin/Menu/: ui_msg.c cx_menu.c Keyboard.c ui_files.c Public_menuDlG.c pysearch.c menu_WindowDLG.c GIF_WindowDLG.c DialogPageDLG.c SwitchDialogPageDLG.c HZ_SongTi_24_4A.c
    ../STemWin/Menu/Analysis/: Patient_Info_WindowDLG.c
    ../STemWin/Menu/analysis/: analysis_menuDLG.c NextSample_WindowDLG.c CountingPrompt_WindowDLG.c ErrorInfo_WindowDLG.c CountFail_WindowDLG.c NSecOutin_In_WindowDLG.c ReCount_WindowDLG.c PrinterErrorPrompt_WindowDLG.c Confirm_Takeout_Cell_WindowDLG.c InputUserNumPageDLG.c PatientListPageDLG.c
    ../STemWin/Menu/ListReview/: ListReview_WindowDLG.c EditResult_WindowDLG.c ResultInfo_WindowDLG.c
    ../STemWin/Menu/serviceItemPage/: agingTestPageDLG.c servicePageDLG.c dataManagePageDLG.c StatusCheckPageDLG.c diskPageDLG.c jiaoHuCheckPageDLG.c logPageDLG.c otherCheckPageDLG.c screenRGBTestPageDLG.c versionPageDLG.c PCBA_PageDLG.c XNCheckPageDLG.c
    ../STemWin/Menu/set/: Calibration_WindowDLG.c lab_infoPageDLG.c ParaSetPageDLG.c debugPageDLG.c SetPageDLG.c dataTimeSetPageDLG.c FuzhuConfigPageDLG.c logoSwitchPageDLG.c PrinterSetPageDLG.c ResetPswPageDLG.c sysConfigPageDLG.c UserManagePageDLG.c AddUserPageDLG.c SetSkinPageDLG.c HGBDebugPageDLG.c
    ../STemWin/Menu/login/: Login_SelfCheck_WindowDLG.c Login_WindowDLG.c
    ../STemWin/Menu/poweroff/: PowerOff_WindowDLG.c
    ../STemWin/Menu/qc/: QC_WindowDLG.c QC_Analysis_WindowDLG.c QC_List_WindowDLG.c QC_Set_WindowDLG.c
  group RL_FlashFS
    ../RL_FlashFS/ARM_Compiler1.6.3/: retarget_io.c
    ../RL_FlashFS/CMSIS-Driver2.6.1/: NAND_MemBus.c NAND_MemBus_Config.h
    ../RL_FlashFS/FileSystem6.13.8/: FS_Config.c FS_Config_NAND_0.h FS_LFN_CM3_L.lib
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_hcd.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_ll_fmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_sdram.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_5.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
  group Middlewares/USB_Host_Library
    ../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
