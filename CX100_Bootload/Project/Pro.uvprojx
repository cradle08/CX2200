# Keil uVision project Pro.uvprojx, settings and files
target STM32F429_DEMO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Boot +hex
  AfterMake: fromelf --bin --output .\Objects\Boot.bin .\Objects\Boot.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx
  c include: ..\BSP;..\FWLibary\CMSIS;..\FWLibary\Driver\inc;..\User;..\FWLibary\USB\OTG;..\FWLibary\USB\Device\Core;..\FWLibary\USB\Device\Class;..\FWLibary\USB\App;..\BSP\FatFS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group FWLib_CMSIS
    ../FWLibary/CMSIS/: startup_stm32f429_439xx.s stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
  group FWLib_src
    ../FWLibary/Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group BSP
    ../BSP/: systick.c usart.c output.c fmc_sdram.c i2cHardPolling.c eeprom.c flash.c SPI_FLASH.c LCD.c fonts.c
  group User
    ../User/: main.c global.c global.h stm32f4xx_it.c stm32f4xx_conf.h
